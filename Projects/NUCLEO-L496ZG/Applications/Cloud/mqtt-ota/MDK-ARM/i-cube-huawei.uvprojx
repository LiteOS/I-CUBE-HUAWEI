# Keil uVision project i-cube-huawei.uvprojx, settings and files
target i-cube-huawei ()
  device: STM32L496ZGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: i-cube-huawei
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 wLevel=2
  c define: __KEIL__=1
  c misc: -DSTM32L496xx -DMQTTCLIENT_PLATFORM_HEADER=paho_osdepends.h -DCONFIG_MQTT_PAHO_ENABLE=1 -DWITH_DTLS -DMBEDTLS_AES_ROM_TABLES -DMBEDTLS_CONFIG_FILE=\"los_mbedtls_config_cert.h\" -DCONFIG_DTLS_MBEDTLS_CERT -DCFG_MBEDTLS_MODE=CRT
  c include: ..\Inc;..\..\mqtt-ota;..\..\..\..\..\..\Projects\NUCLEO-L496ZG\Applications\Cloud\mqtt\Inc;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lis2dw12;..\..\..\..\..\..\Drivers\BSP\Components\lis2mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso;..\..\..\..\..\..\Drivers\BSP\Components\stts751;..\..\..\..\..\..\Drivers\BSP\IKS01A3;..\..\..\..\..\..\Drivers\CMSIS\Core\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\targets\NUCLEO-L496ZG\Inc;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\targets\NUCLEO-L496ZG\OS_CONFIG;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\at;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\cJSON;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\crc;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\driver;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\inc;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\link_misc;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\network\dtls\dtls_al;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\network\dtls\mbedtls\mbedtls-2.16.2\include;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\network\dtls\mbedtls\mbedtls_port;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\oc\oc_mqtt\oc_mqtt_al;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\oc\oc_mqtt\oc_mqtt_profile_v5;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\queue;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\storage;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\osal;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\arch\arm\arm-m\armv7-m;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\arch\arm\arm-m\include;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\arch\arm\common\cmsis;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\base\include;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\cmsis;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\extended\include;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\include;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\fs\inc;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\network\mqtt\paho_mqtt\paho\MQTTClient-C\src;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\network\mqtt\paho_mqtt\paho\MQTTPacket\src;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\network\mqtt\paho_mqtt\port;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\network\dtls\mbedtls\mbedtls-2.16.2\include;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\network\dtls\mbedtls\mbedtls_port;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\link_ota;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\targets\NUCLEO-L496ZG\Src\ota_flash;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\link_ota\download\https;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\link_ota\download_check\sha256check
  library: MicroLIB
  scatter file: .\link.sct
  link misc: --entry Reset_Handler --keep *.o(osdriv) --keep *.o(oshell)
  group Middlewares/Third_Party/Huawei/System
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/osal/: osal.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/arch/arm/arm-m/armv7-m/keil/: los_startup.S los_dispatch.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/arch/arm/arm-m/armv7-m/: los_exc.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/mem/heap/: los_heap.c los_memory.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/mem/membox/: los_membox.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/mem/common/: los_slab.c los_slabmem.c los_memcheck.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/misc/: los_misc.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/om/: los_err.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/cmsis/: cmsis_liteos.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/utils/: rbtree.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/: liteos_errno.c liteos_imp.c los_init.c malloc.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/queue/: queue.c
  group Middlewares/Third_Party/Huawei/Driver
    ../../../../../../Middlewares/Third_Party/Huawei/targets/NUCLEO-L496ZG/Src/: uart_debug.c uart_at.c
    ../Src/: app_x-cube-mems1.c stm32l4xx_hal_msp.c stm32l4xx_it.c stm32l4xx_nucleo_bus.c system_stm32l4xx.c
    ../: board.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c
  group Drivers/BSP/IKS
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Application/IoT_SDK
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/: link_main.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/link_misc/: link_ring_buffer.c link_string.c link_random.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/link_log/: link_log.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/at/: at.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/cJSON/: cJSON.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/driver/: driver.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/shell/: shell_main.c shell_cmd.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/stimer/: stimer.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/demos/: app_demo_main.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/network/tcpip/fibocom_l716_cn_socket/: fibocom_l716_cn_imp.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/network/tcpip/sal/: sal.c sal_netdb.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/network/mqtt/mqtt_al/: mqtt_al.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/network/mqtt/paho_mqtt/port/: paho_mqtt_port.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/network/mqtt/paho_mqtt/paho/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/network/mqtt/paho_mqtt/paho/MQTTClient-C/src/: MQTTClient.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/network/dtls/dtls_al/: dtls_al.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/network/dtls/mbedtls/mbedtls-2.16.2/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/network/dtls/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c mbed_port.c net_sockets_alt.c timing_alt.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/oc/oc_mqtt/oc_mqtt_al/: oc_mqtt_al.c oc_mqtt_at.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/oc/oc_mqtt/oc_mqtt_profile_v5/: oc_mqtt_profile.c oc_mqtt_profile_package.c oc_mqtt_event.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/oc/oc_mqtt/oc_mqtt_tiny_v5/: hmac.c oc_mqtt_tiny.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/link_ota/: ota_flag.c ota_img.c ota_init.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/crc/: crc32.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/link_ota/download/https/: ota_https.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/link_ota/download_check/sha256check/: sha256_check.c
  group Application/Demo
    ../../../../../../Middlewares/Third_Party/Huawei/targets/NUCLEO-L496ZG/Src/: iot_main.c __aeabi_assert.c
    ../: oc_demo.c
    ../../../../../../Middlewares/Third_Party/Huawei/targets/NUCLEO-L496ZG/Src/ota_flash/: flash_ota_img.c hal_flash.c
