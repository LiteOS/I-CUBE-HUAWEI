# Keil uVision project loader.uvprojx, settings and files
target loader ()
  device: STM32L496ZGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: loader
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 wLevel=2
  c define: __KEIL__=1
  c misc: -DSTM32L496xx -D_CompressPlugin_lzma
  c include: ..\Inc;..\..\loader;..\..\..\..\..\..\Projects\NUCLEO-L496ZG\Applications\Cloud\loader\Inc;..\..\..\..\..\..\Drivers\CMSIS\Core\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\targets\NUCLEO-L496ZG\Inc;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\targets\NUCLEO-L496ZG\OS_CONFIG;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\cJSON;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\crc;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\driver;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\inc;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\link_misc;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\queue;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\storage;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\osal;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\arch\arm\arm-m\armv7-m;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\arch\arm\arm-m\include;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\arch\arm\common\cmsis;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\base\include;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\cmsis;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\extended\include;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\os\liteos\include;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\fs\inc;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\link_ota;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\link_ota\compress\lzma\C;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\link_ota\differential\HDiffPatch;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\iot_link\link_ota\patch;..\..\..\..\..\..\Middlewares\Third_Party\Huawei\targets\NUCLEO-L496ZG\Src\ota_flash
  library: MicroLIB
  scatter file: .\link.sct
  link misc: --entry Reset_Handler --keep *.o(oshell)
  group Middlewares/Third_Party/Huawei/System
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/osal/: osal.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/arch/arm/arm-m/armv7-m/keil/: los_startup.S los_dispatch.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/arch/arm/arm-m/armv7-m/: los_exc.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/mem/heap/: los_heap.c los_memory.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/mem/membox/: los_membox.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/mem/common/: los_slab.c los_slabmem.c los_memcheck.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/misc/: los_misc.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/base/om/: los_err.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/cmsis/: cmsis_liteos.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/utils/: rbtree.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/os/liteos/: liteos_errno.c liteos_imp.c los_init.c malloc.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/queue/: queue.c
  group Middlewares/Third_Party/Huawei/Driver
    ../../../../../../Middlewares/Third_Party/Huawei/targets/NUCLEO-L496ZG/Src/: uart_debug.c
    ../Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c stm32l4xx_nucleo_bus.c system_stm32l4xx.c
    ../: board.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c
  group Application/IoT_SDK
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/: link_main.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/link_misc/: link_ring_buffer.c link_string.c link_random.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/link_log/: link_log.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/shell/: shell_main.c shell_cmd.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/stimer/: stimer.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/demos/: app_demo_main.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/link_ota/: ota_flag.c ota_img.c ota_init.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/link_ota/compress/lzma/C/: Lzma2Dec.c LzmaDec.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/link_ota/differential/HDiffPatch/libHDiffPatch/HPatch/: patch.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/link_ota/patch/: ota_patch.c
    ../../../../../../Middlewares/Third_Party/Huawei/iot_link/crc/: crc32.c
  group Application/Demo
    ../../../../../../Middlewares/Third_Party/Huawei/targets/NUCLEO-L496ZG/Src/: iot_main.c __aeabi_assert.c
    ../: loader.c
    ../../../../../../Middlewares/Third_Party/Huawei/targets/NUCLEO-L496ZG/Src/ota_flash/: flash_ota_img.c hal_flash.c
